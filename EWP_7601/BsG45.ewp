# IAR project BsG45.ewp, settings and files
configuration Bs9g45_sram (ARM, debug)
  General.OGChipSelectEditMenu: at91sam9g45 Atmel at91sam9g45
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 12
  General.FPU2: 0
  ICCARM.CCDefines: at91sam9g45; BS_G45_SRAM; BS_G45_TEST; LCD_INV_TYPE; USE_PIO_SYNC; TRACE_LEVEL=4
  ICCARM.CCDiagSuppress: Pe826,Pe1375
  ICCARM.CCIncludePath2: ..\LibG45/peripherals; ..\LibG45/components; ..\LibG45/usb/device; ..\LibG45\drivers; ..\LibG45; ..\external_libs; ..\LibG45/boards/bs_g45; ..\inc; ..\ici; ..\inc/modbus; ..\inc/memory_map; ..\DriverRS485; ..\mal\inc; ..\Gui\; ..\gui_func\inc\; ..\emW\Core; ..\emW\Config; ..\emW\ConvertIMG; ..\emW\WM; ..\emW\Widget
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: at91sam9g45; ddram; TRACE_LEVEL=4
  AARM.AUserIncludes: ..\LibG45\peripherals; ..\LibG45\usb\device; ..\LibG45\boards\bs_g45; ..\LibG45\; external_libs; at91lib/boards/at91sam9g45-ek
  OBJCOPY.OOCOutputFile: g45_i7601_sram.bin
  ILINK.IlinkOutputFile: g45_i7601_sram.out
  ILINK.IlinkIcfFile: sram.icf
  ILINK.IlinkAdditionalLibs: ./Debug/Exe/emW_V1.a
  ILINK.IlinkProgramEntryLabel: resetHandler
configuration Bs9g45_flash (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: at91sam9g45; BS_G45_FL_RL; BS_G45_FLASH; BS_G45_TEST; LCD_INV_TYPE; USE_PIO_SYNC; TRACE_LEVEL=0
  ICCARM.CCIncludePath2: ..\LibG45\peripherals; ..\LibG45\usb/device; ..\LibG45\drivers; ..\LibG45\boards/bs_g45; ..\LibG45\; ..\external_libs; ..\inc; ..\inc/modbus; ..\inc/memory_map; ..\ici; ..\DriverRS485; ..\mal\inc; ..\Gui\; ..\gui_func\inc\; ..\emW\Core; ..\emW\Config; ..\emW\ConvertIMG; ..\emW\WM; ..\emW\Widget
  AARM.ADefines: at91sam9g45; BS_G45_FL_RL; TRACE_LEVEL=4
  AARM.AUserIncludes: ..\LibG45\peripherals; ..\LibG45\usb/device; ..\LibG45\boards/bs_g45; ..\LibG45\; ..\external_libs
  OBJCOPY.OOCOutputFile: Bs9g45_flash.bin
  ILINK.IlinkOutputFile: Bs9g45_flash.out
  ILINK.IlinkIcfFile: flash.icf
configuration IRAM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: at91sam9g45; ddram; TRACE_LEVEL=4
  ICCARM.CCIncludePath2: at91lib/peripherals; at91lib/components; at91lib; external_libs; at91lib/boards/at91sam9g45-ek; ..\..\..\at91lib/peripherals; ..\..\..\at91lib/components; ..\..\..\at91lib; ..\..\..\external_libs; ..\..\..\at91lib/boards/at91sam9g45-ek; LibG45/peripherals; \LibG45/usb/device; LibG45/boards/bs_g45; \LibG45/
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: at91lib/peripherals; at91lib/components; at91lib; external_libs; at91lib/boards/at91sam9g45-ek; LibG45/peripherals; \LibG45/usb/device; LibG45/boards/bs_g45; \LibG45/
  OBJCOPY.OOCOutputFile: Bs9g45_sram.bin
  ILINK.IlinkOutputFile: Bs9g45_sram.out
  ILINK.IlinkIcfFile: EWP\iram.icf
configuration Bs_G45_sram_sml (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: at91sam9g45; BS_G45_SRAM; ddram; BS_G45_TEST; TRACE_LEVEL=4
  ICCARM.CCIncludePath2: ..\LibG45/peripherals; ..\LibG45/components; ..\LibG45/usb/device; ..\LibG45; ..\external_libs; ..\LibG45/boards/bs_g45; ..\inc; ..\ici; ..\inc/modbus; ..\DriverRS485
  OBJCOPY.OOCOutputFile: Bs9g45_sram.bin
  ILINK.IlinkOutputFile: Bs9g45_sram.out
configuration Bs_G45_ddr (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: at91sam9g45; BS_G45_SRAM; ddram; BS_G45_TEST; TRACE_LEVEL=4
  OBJCOPY.OOCOutputFile: BsG45.bin
  ILINK.IlinkOutputFile: Bs_g45_ddr.out
  ILINK.IlinkIcfFile: srmDdr.icf
  group at91lib/boards/bs_g45
    ../LibG45/boards/bs_g45/at91sam9g45/: arm926ej_cp15_drv.c
    ../LibG45/boards/bs_g45/: board.h board_cstartup_iar.s board_lowlevel.c board_lowlevel.h board_memories.c
  group at91lib/boards/bs_g45/at91sam9g45
    LibG45/boards/bs_g45/at91sam9g45/: AT91SAM9G45.h chip.h
    ../LibG45/boards/bs_g45/at91sam9g45/: CoreInit.c
  group at91lib/drv/dmad
    ../LibG45/drivers/dmad/: dmad.c dmad.h
  group at91lib/memories/spi-flash
    ../LibG45/memories/spi-flash/: spid.c spid.h
  group at91lib/peripherals/cp15
    ../LibG45/peripherals/cp15/: cp15.c cp15.h cp15_asm_iar.s
  group at91lib/peripherals/dbgu
    ../LibG45/peripherals/dbgu/: dbgu.c dbgu.h
  group at91lib/peripherals/dma
    ../LibG45/peripherals/dma/: dma.c dma.h
  group at91lib/peripherals/irq
    ../LibG45/peripherals/irq/: aic.c
    $EW_DIR$/arm/examples/Atmel/at91lib/peripherals/irq/: irq.h
  group at91lib/peripherals/lcd
    ../LibG45/peripherals/lcd/: lcd.c lcd.h
  group at91lib/peripherals/pio
    ../LibG45/peripherals/pio/: pio.c pio.h pio_it.c pio_it.h
  group at91lib/peripherals/pit
    ../LibG45/peripherals/pit/: pit.c pit.h
  group at91lib/peripherals/pmc
    ../LibG45/peripherals/pmc/: pmc.c pmc.h
  group at91lib/peripherals/spi
    ../LibG45/peripherals/spi/: spi.c spi.h
  group at91lib/peripherals/tc
    ../LibG45/peripherals/tc/: tc.c
    $EW_DIR$/arm/examples/Atmel/at91lib/peripherals/tc/: tc.h
  group at91lib/peripherals/usart
    ../LibG45/peripherals/usart/: usart.c usart.h
  group at91lib/peripherals/usb/common/cdc
    ../LibG45/usb/common/cdc/: CDCAbstractControlManagementDescriptor.h CDCCallManagementDescriptor.h CDCCommunicationInterfaceDescriptor.h CDCDataInterfaceDescriptor.h CDCDeviceDescriptor.h CDCGenericDescriptor.h CDCGenericRequest.h CDCHeaderDescriptor.h CDCLineCoding.c CDCLineCoding.h CDCSetControlLineStateRequest.c CDCSetControlLineStateRequest.h CDCUnionDescriptor.h
  group at91lib/peripherals/usb/common/core
    ../LibG45/usb/common/core/: USBConfigurationDescriptor.c USBConfigurationDescriptor.h USBDeviceDescriptor.h USBDeviceQualifierDescriptor.h USBEndpointDescriptor.c USBEndpointDescriptor.h USBFeatureRequest.c USBFeatureRequest.h USBGenericDescriptor.c USBGenericDescriptor.h USBGenericRequest.c USBGenericRequest.h USBGetDescriptorRequest.c USBGetDescriptorRequest.h USBInterfaceDescriptor.h USBInterfaceRequest.c USBInterfaceRequest.h USBSetAddressRequest.c USBSetAddressRequest.h USBSetConfigurationRequest.c USBSetConfigurationRequest.h USBStringDescriptor.h
  group at91lib/peripherals/usb/device/cdc-serial
    ../LibG45/usb/device/cdc-serial/: CDCDSerialDriver.c CDCDSerialDriver.h CDCDSerialDriverDescriptors.c CDCDSerialDriverDescriptors.h
  group at91lib/peripherals/usb/device/core
    ../LibG45/usb/device/core/: USBD.h USBD_OTGHS.c USBD_UDP.c USBD_UDPHS.c USBDCallbacks.h USBDCallbacks_Initialized.c USBDCallbacks_Reset.c USBDDriver.c USBDDriver.h USBDDriverCallbacks.h USBDDriverCb_CfgChanged.c USBDDriverCb_IfSettingChanged.c USBDDriverDescriptors.h
  group at91lib/utilities
    ../LibG45/utility/: led.c led.h
  group bin_pc/ici
    ../ici/: communication_functions.c start_settings.c usb_driver.c
  group bin_pc/ici/memory_map
    ../ici/memory_map/: memory_map_functions.c
  group bin_pc/ici/modbus
    ../ici/modbus/: modbus.c modbus_exceptions_handler.c modbus_functions.c
  group bin_pc/inc
    ../inc/: communication_constants.h usb_definitions.h
  group bin_pc/inc/memory_map
    ../inc/memory_map/: const_modbus_memory_map.h memory_map_functions.h memory_map_functions_external.h memory_map_header.h memory_map_type_definition.h
  group bin_pc/inc/modbus
    ../inc/modbus/: const_modbus_memory_map.h modbus_constants.h modbus_functions.h modbus_functions_external.h modbus_header.h modbus_variables.h modbus_variables_external.h
    ../inc/: memory_map_type_definition.h
  group BsG45-prj
    ../: main.c
  group BsG45-prj/gui
    ../Gui/: KbdDrv.c KbdDrv.h lcddrv.c lcddrv.h
  group BsG45-prj/gui_func/dlg
    ../gui_func/dlg/: LanguageDLG.c rank_an_rec_dlg.c rank_df_dlg.c rank_di_dlg.c rank_do_dlg.c rank_led_dlg.c WindingDLG.c
  group BsG45-prj/gui_func/ici
    ../gui_func/ici/: gui_functions.c gui_rank_func.c gui_start_settings.c
  group BsG45-prj/gui_func/img
    ../gui_func/img/: icons.c
  group BsG45-prj/gui_func/inc
    ../gui_func/inc/: gui_const.h gui_functions.h gui_functions_external.h gui_header.h gui_lib_header.h gui_macroses.h gui_rank_const.h gui_variables.h gui_variables_external.h language_const.h
  group BsG45-prj/gui_func/panels
    ../gui_func/panels/: configuration_panel.c main_panel.c measurement_panel.c ranking_panel.c
  group BsG45-prj/ici
    ../ici/: AppCn.c CTpu.c gdma.c GSpi.c GSpi0.c GU.c GU0.c GU2.c ici_api.c lpu.c Tc_g45.c
  group BsG45-prj/mal/inc
    ../mal/inc/: _Protection_panel.h About_panel.h APV_panel.h CB_panel.h Clock_panel.h Comm_panel.h const_ar.h const_global_mal.h const_global_ZigBee.h const_menu_mal.h constants_mal.h Diagnostics_panel.h diagnostyka_mal.h dialogs_mal.h DZ_panel.h EEPROM_RTC_DataFlash.h external_variables_for_global_mal.h functions_external_mal.h functions_global_mal.h General_titles_panel.h header_mal.h LCD_Settings_panel.h libraries_mal.h macroses_mal.h main_menu.h Modbus_panel.h mtz_panel.h Net_panel.h pickup_interval.h Registrators_panel.h Resurs_panel.h Settings_panel.h TM_panel.h Transformer_panel.h type_definition_DDR2.h type_definition_mal.h TZNP_panel.h Umax_panel.h Umin_panel.h UROV_panel.h variables_external_mal.h variables_global_mal.h variables_global_ZigBee.h ZOP_panel.h
  group BsG45-prj/mal/src
    ../mal/src/: About.c APV_panel.c ar_functions.c CB_panel.c Clock_panel.c Comm_panel.c dialogs_mal.c Driver_ZigBee.c DZ_panel.c EEPROM_RTC_DataFlash.c icons_mal.c Info_n_panel.c LCD_mal.c LCD_Settings.c main_menu.c menu.c Modbus_panel.c mtz_panel.c Net_panel.c overload_functions.c Protection_panel.c Registrator_panel.c repaint_actions.c Resurs_panel.c Settings_panel.c string_mal.c tasks.c timer.c Transformer_panel.c TZNP_panel.c Umax_panel.c Umin_panel.c UROV_panel.c ZOP_panel.c
  group BsG45-prj/rce
    ../rce/: spi1.c spi1.h Spi_D.c Spi_D.h SpiD_Dma.c
  group DCC
    ../DCC/: JLINKDCC_HandleDataAbort.s JLINKDCC_Process.c
  group DriverRS485
    ../DriverRS485/: constant.h driverRS485.c driverRS485_extern.h driverRS485_global.h LibRS485.h variables_extern.h variables_global.h
