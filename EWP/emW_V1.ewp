# IAR project emW_V1.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT91SAM9G45 Atmel AT91SAM9G45
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 12
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\LibG45\peripherals; ..\LibG45\usb/device; ..\LibG45\boards/bs_g45; ..\LibG45\; ..\external_libs; ..\emW\AntiAlias; ..\emW\ConvertMono; ..\emW\ConvertColor; ..\emW\Core; ..\emW\Font; ..\emW\DisplayDriver; ..\emW\MemDev; ..\emW\VNC; ..\emW\Widget; ..\emW\WM; ..\emW\Config
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: emW_V1.out
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
configuration BS_G45_SRAM (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCOptLevel: 1
configuration BS_G45_Fl (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group AntiAlias
    ../emW/Antialias/: GUIAA_Arc.c GUIAA_Char.c GUIAA_Char2.c GUIAA_Char2Ext.c GUIAA_Char2Ext_XBF.c GUIAA_Char4.c GUIAA_Char4Ext.c GUIAA_Char4Ext_XBF.c GUIAA_Circle.c GUIAA_DrawRoundedRect.c GUIAA_FillRoundedRect.c GUIAA_Lib.c GUIAA_Line.c GUIAA_Poly.c GUIAA_PolyOut.c GUIAA_SIF2.c GUIAA_SIF2Ext.c GUIAA_SIF4.c GUIAA_SIF4Ext.c
  group Config
    ../emW/Config/: GUIConf.c GUIConf.h LCDConf.c LCDConf.h SIMConf.c
  group ConvertColor
    ../emW/ConvertColor/: GUICC_111.c GUICC_16.c GUICC_1616I.c GUICC_222.c GUICC_233.c GUICC_323.c GUICC_332.c GUICC_444_12.c GUICC_444_12_1.c GUICC_444_16.c GUICC_555.c GUICC_556.c GUICC_565.c GUICC_655.c GUICC_666.c GUICC_666_9.c GUICC_822216.c GUICC_84444.c GUICC_8666.c GUICC_8666_1.c GUICC_88666I.c GUICC_M1555I.c GUICC_M233.c GUICC_M323.c GUICC_M332.c GUICC_M4444I.c GUICC_M444_12.c GUICC_M444_12_1.c GUICC_M444_16.c GUICC_M555.c GUICC_M556.c GUICC_M565.c GUICC_M655.c GUICC_M666.c GUICC_M666_9.c GUICC_M8565.c GUICC_M8888I.c
  group Core
    ../emW/Core/: Global.h GUI.h GUI_2DLib.c GUI__AddSpaceHex.c GUI__Alpha.c GUI__Arabic.c GUI__BiDi.c GUI__BiDiRouting.c GUI__CalcTextRect.c GUI__CompactPixelIndices.c GUI__DivideRound.c GUI__DivideRound32.c GUI__DivTbl_15_255.c GUI__DivTbl_255_15.c GUI__DivTbl_255_31.c GUI__DivTbl_255_63.c GUI__DivTbl_31_255.c GUI__DivTbl_63_255.c GUI__DrawBitmap16bpp.c GUI__DrawTwinArc.c GUI__ExpandPixelIndices.c GUI__GetCursorPos.c GUI__GetFontSizeY.c GUI__GetNumChars.c GUI__HandleEOLine.c GUI__IntersectRect.c GUI__IntersectRects.c GUI__ManageCache.c GUI__memcpy.c GUI__memset.c GUI__memset16.c GUI__Read.c GUI__ReduceRect.c GUI__SetPixelAlpha.c GUI__SetText.c GUI__SinHQ.c GUI__sqrt32.c GUI__strcmp.c GUI__strlen.c GUI__Wrap.c GUI_AddBin.c GUI_AddDec.c GUI_AddDecMin.c GUI_AddDecShift.c GUI_AddHex.c GUI_Alloc.c GUI_ALLOC_AllocInit.c GUI_ALLOC_AllocZero.c GUI_Arc.c GUI_BMP.c GUI_BMP_DrawScaled.c GUI_BMP_EnableAlpha.c GUI_BMP_Private.h GUI_BMP_Serialize.c GUI_CalcColorDist.c GUI_Char.c GUI_CharLine.c GUI_CharM.c GUI_CharP.c GUI_CharPExt.c GUI_CharPFrm.c GUI_Circ.c GUI_ClearRectEx.c GUI_Color2Index.c GUI_Color2VisColor.c GUI_ConfDefaults.h GUI_CopyRect.c GUI_Core.c GUI_Curs1.c GUI_CursAnim.c GUI_CursAnimHourglassM.c GUI_CursorArrowL.c GUI_CursorArrowLI.c GUI_CursorArrowLPx.c GUI_CursorArrowM.c GUI_CursorArrowMI.c GUI_CursorArrowMPx.c GUI_CursorArrowS.c GUI_CursorArrowSI.c GUI_CursorArrowSPx.c GUI_CursorCrossL.c GUI_CursorCrossLI.c GUI_CursorCrossLPx.c GUI_CursorCrossM.c GUI_CursorCrossMI.c GUI_CursorCrossMPx.c GUI_CursorCrossS.c GUI_CursorCrossSI.c GUI_CursorCrossSPx.c GUI_CursorHeaderM.c GUI_CursorHeaderMI.c GUI_CursorHeaderMPx.c GUI_CursorPal.c GUI_CursorPalI.c GUI_Debug.h GUI_Device.c GUI_DirtyDevice.c GUI_DispBin.c GUI_DispCEOL.c GUI_DispChar.c GUI_DispChars.c GUI_DispHex.c GUI_DispString.c GUI_DispStringAt.c GUI_DispStringAtCEOL.c GUI_DispStringHCenter.c GUI_DispStringInRect.c GUI_DispStringInRectEx.c GUI_DispStringInRectWrap.c GUI_DispStringLen.c GUI_DrawBitmap.c GUI_DrawBitmap_24.c GUI_DrawBitmap_444.c GUI_DrawBitmap_555.c GUI_DrawBitmap_565.c GUI_DrawBitmap_888.c GUI_DrawBitmap_8888.c GUI_DrawBitmapEx.c GUI_DrawBitmapExp.c GUI_DrawBitmapHWAlpha.c GUI_DrawBitmapMag.c GUI_DrawFocusRect.c GUI_DrawGradient.c GUI_DrawGradientRounded.c GUI_DrawGraph.c GUI_DrawGraphEx.c GUI_DrawHLine.c GUI_DrawLine.c GUI_DrawPie.c GUI_DrawPixel.c GUI_DrawPoint.c GUI_DrawPolygon.c GUI_DrawPolyline.c GUI_DrawRectEx.c GUI_DrawRoundedFrame.c GUI_DrawRoundedRect.c GUI_DrawVLine.c GUI_EnableAlpha.c GUI_EncExt.c GUI_EncJS.c GUI_Error.c GUI_ErrorOut.c GUI_Exec.c GUI_FillPolygon.c GUI_FillRect.c GUI_FillRectEx.c GUI_FillRoundedRect.c GUI_FontIntern.h GUI_GetBitmapPixelColor.c GUI_GetBitmapPixelIndex.c GUI_GetBlankCols.c GUI_GetClientRect.c GUI_GetColor.c GUI_GetDispPos.c GUI_GetDrawMode.c GUI_GetFont.c GUI_GetFontInfo.c GUI_GetFontSizeY.c GUI_GetLineStyle.c GUI_GetOrg.c GUI_GetStringDistX.c GUI_GetTextAlign.c GUI_GetTextExtend.c GUI_GetTextMode.c GUI_GetVersionString.c GUI_GetYSizeOfFont.c GUI_GIF.c GUI_GIF_DrawScaled.c GUI_GIF_Private.h GUI_Goto.c GUI_Index2Color.c GUI_InvertRect.c GUI_IsInFont.c GUI_JOYSTICK.c GUI_JPEG.c GUI_JPEG_DrawScaled.c GUI_JPEG_Private.h GUI_Lang.c GUI_Log.c GUI_MergeRect.c GUI_MOUSE.c GUI_MOUSE_DriverPS2.c GUI_MoveRect.c GUI_MULTIBUF.c GUI_OnKey.c GUI_Pen.c GUI_PID.c GUI_PolyEnlarge.c GUI_PolyMagnify.c GUI_PolyRotate.c GUI_Private.h GUI_Realloc.c GUI_RectsIntersect.c GUI_SaveContext.c GUI_ScreenSize.c GUI_SelectLayer.c GUI_SelectLCD.c GUI_SetAlpha.c GUI_SetClipRect.c GUI_SetColor.c GUI_SetColorIndex.c GUI_SetDecChar.c GUI_SetDefault.c GUI_SetDrawMode.c GUI_SetFont.c GUI_SetLBorder.c GUI_SetLineStyle.c GUI_SetOrg.c GUI_SetOrientation.c GUI_SetOrientation.h GUI_SetOrientationC0.c GUI_SetOrientationC16.c GUI_SetOrientationC32.c GUI_SetOrientationC8.c GUI_SetOrientationCX.h GUI_SetPixelIndex.c GUI_SetTextAlign.c GUI_SetTextMode.c GUI_SetTextStyle.c GUI_SIF.c GUI_SIF_Prop.c GUI_SIF_PropExt.c GUI_SIF_PropExtFrmInfo.c GUI_SIF_PropFrm.c GUI_SPRITE.c GUI_SPRITE_Anim.c GUI_Stream.c GUI_StreamCreate.c GUI_Task.c GUI_Time.c GUI_Timer.c GUI_TOUCH.c GUI_TOUCH_DriverAnalog.c GUI_TOUCH_StoreState.c GUI_TOUCH_StoreUnstable.c GUI_Type.h GUI_UC.c GUI_UC0.c GUI_UC_ConvertUC2UTF8.c GUI_UC_ConvertUTF82UC.c GUI_UC_DispString.c GUI_UC_EnableBIDI.c GUI_UC_EncodeNone.c GUI_UC_EncodeUTF8.c GUI_Val.c GUI_Valf.c GUI_Version.h GUI_VNC.h GUI_WaitEvent.c GUI_WaitKey.c GUI_Warn.c GUI_XBF.c GUI_XBF_Prop.c GUI_XBF_PropExt.c GUI_XBF_PropFrm.c GUICC_0.c GUICC_1.c GUICC_444_12_1_Index2Color.c GUICC_444_12_Index2Color.c GUICC_444_16_Index2Color.c GUICC_555_Index2Color.c GUICC_565_Index2Color.c GUICC_888.c GUICC_8888.c GUICC_8888_Index2Color.c GUICC_888_Index2Color.c GUICC_BW.c GUICC_M444_12_1_Index2Color.c GUICC_M444_12_Index2Color.c GUICC_M444_16_Index2Color.c GUICC_M555_Index2Color.c GUICC_M565_Index2Color.c GUICC_M888.c GUICC_M8888.c GUICC_M888_Index2Color.c LCD.c LCD.h LCD_AA.c LCD_Color.c LCD_ConfDefaults.h LCD_ControlCache.c LCD_GetColorIndex.c LCD_GetEx.c LCD_GetNumDisplays.c LCD_GetP.c LCD_GetPixelColor.c LCD_Index2ColorEx.c LCD_Info.c LCD_Mirror.c LCD_MixColors256.c LCD_NextPixelAPI.c LCD_Private.h LCD_Protected.h LCD_ReadRect.c LCD_RLE16.c LCD_RLE32.c LCD_RLE4.c LCD_RLE8.c LCD_RLEAlpha.c LCD_Rotate180.c LCD_RotateCCW.c LCD_RotateCW.c LCD_SelectLCD.c LCD_Set.c LCD_SetClipRectEx.c LCD_SIM.h LCD_UpdateColorIndices.c
  group DisplayDriver
    ../emW/DisplayDriver/: GUIDRV_DCache.c GUIDRV_DCache.h GUIDRV_DCache_1bpp.c GUIDRV_DCache_Private.h GUIDRV_Dist.c GUIDRV_Dist.h GUIDRV_Generic.h GUIDRV_Lin.h GUIDRV_Lin_1.c GUIDRV_Lin_16.c GUIDRV_Lin_2.c GUIDRV_Lin_24.c GUIDRV_Lin_32.c GUIDRV_Lin_4.c GUIDRV_Lin_8.c GUIDRV_Lin_Opt_16.h GUIDRV_Lin_Opt_24.h GUIDRV_Lin_Opt_32.h GUIDRV_Lin_Opt_8.h GUIDRV_Lin_OS_16.c GUIDRV_Lin_OS_24.c GUIDRV_Lin_OS_32.c GUIDRV_Lin_OSX_16.c GUIDRV_Lin_OSX_24.c GUIDRV_Lin_OSX_32.c GUIDRV_Lin_OSX_8.c GUIDRV_Lin_OSY_16.c GUIDRV_Lin_OSY_24.c GUIDRV_Lin_OSY_32.c GUIDRV_Lin_OSY_8.c GUIDRV_Lin_OX_16.c GUIDRV_Lin_OX_24.c GUIDRV_Lin_OX_32.c GUIDRV_Lin_OX_8.c GUIDRV_Lin_OXY_16.c GUIDRV_Lin_OXY_24.c GUIDRV_Lin_OXY_32.c GUIDRV_Lin_OXY_8.c GUIDRV_Lin_OY_16.c GUIDRV_Lin_OY_24.c GUIDRV_Lin_OY_32.c GUIDRV_Lin_Private.h GUIDRV_NoOpt_1_8.c GUIDRV_NoOpt_1_8.h GUIDRV_Template.c GUIDRV_Template.h GUIDRV_TemplateI.c GUIDRV_TemplateI.h GUIDRV_TemplateI_Private.h GUIDRV_TemplateI_X_16.c GUIDRV_Win32.c
  group Font
    ../emW/Font/: ArialBold14_8_Unicode.c ArialBold15_9_Unicode.c ArialBold16_10_Unicode.c ArialBold19_12_Unicode.c ArialNarrow15_8_Unicode.c ArialStandard14_8_Unicode.c ArialStandard15_9_Unicode.c ArialStandard16_10_Unicode.c ArialStandard18_12_Unicode.c CourierNewBold14_8_Unicode.c CourierNewStandard14_8_Unicode.c F08_1.c F08_ASCII.c F10_1.c F10_ASCII.c F10S_1.c F10S_ASCII.c F13_1.c F13_ASCII.c F13B_1.c F13B_ASCII.c F13H_1.c F13H_ASCII.c F13HB_1.c F13HB_ASCII.c F16_1.c F16_1HK.c F16_ASCII.c F16_HK.c F16B_1.c F16B_ASCII.c F20_1.c F20_ASCII.c F20B_1.c F20B_ASCII.c F20F_ASCII.c F24_1.c F24_ASCII.c F24B_1.c F24B_ASCII.c F32_1.c F32_ASCII.c F32B_1.c F32B_ASCII.c F4x6.c F6x8.c F6x8_1.c F6x8_ASCII.c F8x10_ASCII.c F8x12_ASCII.c F8x13_1.c F8x13_ASCII.c F8x15B_1.c F8x15B_ASCII.c F8x16.c F8x16_1.c F8x16_ASCII.c F8x8.c F8x8_1.c F8x8_ASCII.c FComic18B_1.c FComic18B_ASCII.c FComic24B_1.c FComic24B_ASCII.c FD24x32.c FD32.c FD36x48.c FD48.c FD48x64.c FD60x80.c FD64.c FD80.c
  group MemDev
    ../emW/MemDev/: GUIDEV.c GUIDEV_1.c GUIDEV_16.c GUIDEV_32.c GUIDEV_8.c GUIDEV_AA.c GUIDEV_Auto.c GUIDEV_Banding.c GUIDEV_Clear.c GUIDEV_CmpWithLCD.c GUIDEV_CopyFromLCD.c GUIDEV_CreateFixed.c GUIDEV_GetDataPtr.c GUIDEV_GetPos.c GUIDEV_GetXSize.c GUIDEV_GetYSize.c GUIDEV_Measure.c GUIDEV_MoveAndFade.c GUIDEV_MoveAndFadeWin.c GUIDEV_Perspective.c GUIDEV_ReadLine.c GUIDEV_ReduceYSize.c GUIDEV_Rotate.c GUIDEV_RotateTrans.c GUIDEV_Serialize.c GUIDEV_SetColorConv.c GUIDEV_SetOrg.c GUIDEV_StaticDevices.c GUIDEV_Usage.c GUIDEV_UsageBM.c GUIDEV_Write.c GUIDEV_WriteAlpha.c GUIDEV_WriteEx.c GUIDEV_WriteToActiveAlpha.c GUIDEV_WriteToActiveOpaque.c GUIDEV_XY2PTR.c
  group Sample
    ../emW/Sample/GUI_X/: GUI_X.c
  group Widget
    ../emW/Widget/: BUTTON.c BUTTON.h BUTTON__SetBitmapObj.c BUTTON_Bitmap.c BUTTON_BMP.c BUTTON_Color.c BUTTON_Create.c BUTTON_CreateIndirect.c BUTTON_Default.c BUTTON_Get.c BUTTON_GetBitmap.c BUTTON_IsPressed.c BUTTON_Private.h BUTTON_SelfDraw.c BUTTON_SetFocusColor.c BUTTON_SetTextAlign.c BUTTON_Skin.c BUTTON_SkinClassic.c BUTTON_SkinFlex.c BUTTON_StreamedBitmap.c CALENDAR.c CALENDAR.h CHECKBOX.c CHECKBOX.h CHECKBOX_Create.c CHECKBOX_CreateIndirect.c CHECKBOX_Default.c CHECKBOX_GetState.c CHECKBOX_GetText.c CHECKBOX_Image.c CHECKBOX_IsChecked.c CHECKBOX_Private.h CHECKBOX_SetBkColor.c CHECKBOX_SetBoxBkColor.c CHECKBOX_SetDefaultImage.c CHECKBOX_SetFocusColor.c CHECKBOX_SetFont.c CHECKBOX_SetImage.c CHECKBOX_SetNumStates.c CHECKBOX_SetSpacing.c CHECKBOX_SetState.c CHECKBOX_SetText.c CHECKBOX_SetTextAlign.c CHECKBOX_SetTextColor.c CHECKBOX_Skin.c CHECKBOX_SkinClassic.c CHECKBOX_SkinFlex.c CHOOSECOLOR.c CHOOSECOLOR.h CHOOSEFILE.c CHOOSEFILE.h DIALOG.c DIALOG.h DIALOG_Intern.h DROPDOWN.c DROPDOWN.h DROPDOWN_AddString.c DROPDOWN_Create.c DROPDOWN_CreateIndirect.c DROPDOWN_Default.c DROPDOWN_DeleteItem.c DROPDOWN_Expanded.c DROPDOWN_GetNumItems.c DROPDOWN_InsertString.c DROPDOWN_ItemDisabled.c DROPDOWN_ItemSpacing.c DROPDOWN_Private.h DROPDOWN_SetAutoScroll.c DROPDOWN_SetBkColor.c DROPDOWN_SetColor.c DROPDOWN_SetFont.c DROPDOWN_SetScrollbarColor.c DROPDOWN_SetScrollbarWidth.c DROPDOWN_SetTextAlign.c DROPDOWN_SetTextColor.c DROPDOWN_SetTextHeight.c DROPDOWN_Skin.c DROPDOWN_SkinClassic.c DROPDOWN_SkinFlex.c EDIT.c EDIT.h EDIT_Create.c EDIT_CreateIndirect.c EDIT_Default.c EDIT_EnableBlink.c EDIT_GetCursorPixelPos.c EDIT_GetCursorPos.c EDIT_GetNumChars.c EDIT_Private.h EDIT_SetCursorAtChar.c EDIT_SetFocussable.c EDIT_SetInsertMode.c EDIT_SetpfAddKeyEx.c EDIT_SetpfUpdateBuffer.c EDIT_SetSel.c EDIT_SetTextMode.c EDITBin.c EDITDec.c EDITFloat.c EDITHex.c EDITUlong.c FRAMEWIN.c FRAMEWIN.h FRAMEWIN__UpdateButtons.c FRAMEWIN_AddMenu.c FRAMEWIN_Button.c FRAMEWIN_ButtonClose.c FRAMEWIN_ButtonMax.c FRAMEWIN_ButtonMin.c FRAMEWIN_Create.c FRAMEWIN_CreateIndirect.c FRAMEWIN_Default.c FRAMEWIN_Get.c FRAMEWIN_IsMinMax.c FRAMEWIN_MinMaxRest.c FRAMEWIN_Private.h FRAMEWIN_SetBorderSize.c FRAMEWIN_SetColors.c FRAMEWIN_SetFont.c FRAMEWIN_SetOwnerDraw.c FRAMEWIN_SetResizeable.c FRAMEWIN_SetTitleHeight.c FRAMEWIN_SetTitleVis.c FRAMEWIN_Skin.c FRAMEWIN_SkinClassic.c FRAMEWIN_SkinFlex.c GRAPH.c GRAPH.h GRAPH_CreateIndirect.c GRAPH_DATA_XY.c GRAPH_DATA_YT.c GRAPH_Private.h GRAPH_SCALE.c GUI_ARRAY.c GUI_ARRAY.h GUI_ARRAY_DeleteItem.c GUI_ARRAY_InsertItem.c GUI_ARRAY_Private.h GUI_ARRAY_ResizeItem.c GUI_DRAW.c GUI_DRAW_BITMAP.c GUI_DRAW_BMP.c GUI_DRAW_Self.c GUI_DRAW_STREAMED.c GUI_EditBin.c GUI_EditDec.c GUI_EditFloat.c GUI_EditHex.c GUI_EditString.c GUI_HOOK.c GUI_HOOK.h HEADER.c HEADER.h HEADER__SetDrawObj.c HEADER_Bitmap.c HEADER_BMP.c HEADER_Color.c HEADER_Create.c HEADER_CreateIndirect.c HEADER_Default.c HEADER_GetSel.c HEADER_Private.h HEADER_SetDragLimit.c HEADER_SetFixed.c HEADER_Skin.c HEADER_SkinClassic.c HEADER_SkinFlex.c HEADER_StreamedBitmap.c ICONVIEW.c ICONVIEW.h ICONVIEW_EnableStreamAuto.c ICONVIEW_Private.h ICONVIEW_SetWrapMode.c IMAGE.c IMAGE.h IMAGE_Bitmap.c IMAGE_BMP.c IMAGE_DTA.c IMAGE_GIF.c IMAGE_JPEG.c IMAGE_Private.h LISTBOX.c LISTBOX.h LISTBOX_AddStringH.c LISTBOX_Create.c LISTBOX_CreateIndirect.c LISTBOX_Default.c LISTBOX_DeleteItem.c LISTBOX_Font.c LISTBOX_GetItemText.c LISTBOX_GetNumItems.c LISTBOX_GetTextAlign.c LISTBOX_InsertString.c LISTBOX_ItemDisabled.c LISTBOX_ItemSpacing.c LISTBOX_MultiSel.c LISTBOX_Private.h LISTBOX_ScrollStep.c LISTBOX_SetAutoScroll.c LISTBOX_SetBkColor.c LISTBOX_SetOwner.c LISTBOX_SetOwnerDraw.c LISTBOX_SetScrollbarColor.c LISTBOX_SetScrollbarWidth.c LISTBOX_SetString.c LISTBOX_SetTextAlign.c LISTBOX_SetTextColor.c LISTVIEW.c LISTVIEW.h LISTVIEW_Create.c LISTVIEW_CreateIndirect.c LISTVIEW_Default.c LISTVIEW_DeleteAllRows.c LISTVIEW_DeleteColumn.c LISTVIEW_DeleteRow.c LISTVIEW_DisableRow.c LISTVIEW_GetBkColor.c LISTVIEW_GetFont.c LISTVIEW_GetHeader.c LISTVIEW_GetItemText.c LISTVIEW_GetNumColumns.c LISTVIEW_GetNumRows.c LISTVIEW_GetSel.c LISTVIEW_GetTextColor.c LISTVIEW_InsertRow.c LISTVIEW_Private.h LISTVIEW_SetAutoScroll.c LISTVIEW_SetBkColor.c LISTVIEW_SetColumnWidth.c LISTVIEW_SetFixed.c LISTVIEW_SetFont.c LISTVIEW_SetGridVis.c LISTVIEW_SetItemBitmap.c LISTVIEW_SetItemColor.c LISTVIEW_SetItemText.c LISTVIEW_SetLBorder.c LISTVIEW_SetRBorder.c LISTVIEW_SetRowHeight.c LISTVIEW_SetSel.c LISTVIEW_SetSort.c LISTVIEW_SetTextAlign.c LISTVIEW_SetTextColor.c LISTVIEW_SetWrapMode.c LISTVIEW_UserData.c LISTWHEEL.c LISTWHEEL.h LISTWHEEL_Create.c LISTWHEEL_Private.h MENU.c MENU.h MENU__FindItem.c MENU_Attach.c MENU_CreateIndirect.c MENU_Default.c MENU_DeleteItem.c MENU_DisableItem.c MENU_EnableItem.c MENU_GetItem.c MENU_GetItemText.c MENU_GetNumItems.c MENU_InsertItem.c MENU_Popup.c MENU_Private.h MENU_SetBkColor.c MENU_SetBorderSize.c MENU_SetFont.c MENU_SetItem.c MENU_SetTextColor.c MESSAGEBOX.c MESSAGEBOX.h MULTIEDIT.c MULTIEDIT.h MULTIEDIT_Create.c MULTIEDIT_CreateIndirect.c MULTIPAGE.c MULTIPAGE.h MULTIPAGE_Create.c MULTIPAGE_CreateIndirect.c MULTIPAGE_Default.c MULTIPAGE_Private.h MULTIPAGE_SetRotation.c PROGBAR.c PROGBAR.h PROGBAR_Create.c PROGBAR_CreateIndirect.c PROGBAR_Private.h PROGBAR_SetBarColor.c PROGBAR_SetFont.c PROGBAR_SetMinMax.c PROGBAR_SetText.c PROGBAR_SetTextAlign.c PROGBAR_SetTextColor.c PROGBAR_SetTextPos.c PROGBAR_Skin.c PROGBAR_SkinClassic.c PROGBAR_SkinFlex.c RADIO.c RADIO.h RADIO_Create.c RADIO_CreateIndirect.c RADIO_Default.c RADIO_GetText.c RADIO_Image.c RADIO_Private.h RADIO_SetBkColor.c RADIO_SetDefaultImage.c RADIO_SetFocusColor.c RADIO_SetFont.c RADIO_SetGroupId.c RADIO_SetImage.c RADIO_SetText.c RADIO_SetTextColor.c RADIO_Skin.c RADIO_SkinClassic.c RADIO_SkinFlex.c SCROLLBAR.c SCROLLBAR.h SCROLLBAR_Create.c SCROLLBAR_CreateIndirect.c SCROLLBAR_Defaults.c SCROLLBAR_GetNumItems.c SCROLLBAR_GetPageSize.c SCROLLBAR_GetValue.c SCROLLBAR_Private.h SCROLLBAR_SetColor.c SCROLLBAR_SetWidth.c SCROLLBAR_Skin.c SCROLLBAR_SkinClassic.c SCROLLBAR_SkinFlex.c SLIDER.c SLIDER.h SLIDER_Color.c SLIDER_Create.c SLIDER_CreateIndirect.c SLIDER_Default.c SLIDER_Private.h SLIDER_Skin.c SLIDER_SkinClassic.c SLIDER_SkinFlex.c SPINBOX.c SPINBOX.h SPINBOX_CreateIndirect.c SPINBOX_Default.c SPINBOX_Private.h SPINBOX_Skin.c SPINBOX_SkinClassic.c SPINBOX_SkinFlex.c TEXT.c TEXT.h TEXT_Create.c TEXT_CreateIndirect.c TEXT_Default.c TEXT_Get.c TEXT_Private.h TEXT_SetBkColor.c TEXT_SetFont.c TEXT_SetText.c TEXT_SetTextAlign.c TEXT_SetTextColor.c TEXT_SetWrapMode.c TREEVIEW.c TREEVIEW.h TREEVIEW_CreateIndirect.c TREEVIEW_Default.c TREEVIEW_Image.c TREEVIEW_Private.h WIDGET.c WIDGET.h WIDGET_Effect_3D.c WIDGET_Effect_3D1L.c WIDGET_Effect_3D2L.c WIDGET_Effect_None.c WIDGET_Effect_Simple.c WIDGET_FillStringInRect.c WIDGET_SetEffect.c WIDGET_SetWidth.c WINDOW.c WINDOW_Default.c WINDOW_Private.h
  group WM
    ../emW/WM/: WM.c WM.h WM__ForEachDesc.c WM__GetFirstSibling.c WM__GetFocussedChild.c WM__GetLastSibling.c WM__GetOrg_AA.c WM__GetPrevSibling.c WM__IsAncestor.c WM__IsChild.c WM__IsEnabled.c WM__NotifyVisChanged.c WM__Screen2Client.c WM__SendMessage.c WM__SendMessageIfEnabled.c WM__SendMessageNoPara.c WM__UpdateChildPositions.c WM_AttachWindow.c WM_BringToBottom.c WM_BringToTop.c WM_Broadcast.c WM_CheckScrollPos.c WM_CriticalHandle.c WM_DIAG.c WM_EnableWindow.c WM_ForEachDesc.c WM_GetBkColor.c WM_GetCallback.c WM_GetClientRect.c WM_GetClientWindow.c WM_GetDesktopWindow.c WM_GetDesktopWindowEx.c WM_GetDiagInfo.c WM_GetDialogItem.c WM_GetFirstChild.c WM_GetFlags.c WM_GetFocussedWindow.c WM_GetId.c WM_GetInsideRect.c WM_GetInsideRectExScrollbar.c WM_GetInvalidRect.c WM_GetNextSibling.c WM_GetOrg.c WM_GetParent.c WM_GetPrevSibling.c WM_GetScrollbar.c WM_GetScrollPartner.c WM_GetScrollPos.c WM_GetScrollState.c WM_GetWindowRect.c WM_GetWindowSize.c WM_GUI.h WM_HasCaptured.c WM_HasFocus.c WM_Hide.c WM_Intern.h WM_InvalidateArea.c WM_IsCompletelyCovered.c WM_IsCompletelyVisible.c WM_IsEnabled.c WM_IsFocussable.c WM_IsVisible.c WM_IsWindow.c WM_MakeModal.c WM_MemDev.c WM_Motion.c WM_Move.c WM_MoveChildTo.c WM_MULTIBUF.c WM_NotifyParent.c WM_OnKey.c WM_Paint.c WM_PaintWindowAndDescs.c WM_PID__GetPrevState.c WM_ResizeWindow.c WM_Screen2Win.c WM_SendMessageNoPara.c WM_SendToParent.c WM_SetAnchor.c WM_SetCallback.c WM_SetCapture.c WM_SetCaptureMove.c WM_SetCreateFlags.c WM_SetDesktopColor.c WM_SetFocus.c WM_SetFocusOnNextChild.c WM_SetFocusOnPrevChild.c WM_SetId.c WM_SetpfPollPID.c WM_SetScrollbar.c WM_SetScrollPos.c WM_SetScrollState.c WM_SetSize.c WM_SetTrans.c WM_SetTransState.c WM_SetUserClipRect.c WM_SetWindowPos.c WM_SetXSize.c WM_SetYSize.c WM_Show.c WM_SIM.c WM_StayOnTop.c WM_Timer.c WM_ToolTip.c WM_Touch.c WM_UpdateWindowAndDescs.c WM_UserData.c WM_Validate.c WM_ValidateWindow.c
