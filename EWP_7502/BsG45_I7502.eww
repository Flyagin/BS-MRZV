<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\BsG45.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\emW_V1.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>BsG45</project>
        <configuration>Bs9g45_sram</configuration>
      </member>
      <member>
        <project>BsG45</project>
        <configuration>Bs9g45_flash</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


